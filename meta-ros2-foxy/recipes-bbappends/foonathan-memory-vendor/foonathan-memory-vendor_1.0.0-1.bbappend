# Copyright (c) 2019-2020 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    ament-package-native \
    ament-cmake-core \
    ament-copyright-native \
    ament-lint-cmake-native \
    ament-xmllint-native \
    foonathan-memory \
"

inherit python3native
