# Copyright (c) 2020 LG Electronics, Inc.

ROS_TEST_DEPENDS += "rosidl-adapter"

export GTEST_DIR = "${STAGING_EXECPREFIXDIR}"
export GMOCK_DIR = "${STAGING_EXECPREFIXDIR}"
