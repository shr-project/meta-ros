# Copyright (c) 2020 LG Electronics, Inc.
  
ROS_TEST_DEPENDS += "ament-copyright-native ament-lint-cmake-native ament-xmllint-native"
