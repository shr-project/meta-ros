# Copyright (c) 2020 LG Electronics, Inc.

DEPENDS += "ament-copyright-native ament-cppcheck-native ament-cpplint-native ament-lint-cmake-native ament-uncrustify-native ament-xmllint-native"
