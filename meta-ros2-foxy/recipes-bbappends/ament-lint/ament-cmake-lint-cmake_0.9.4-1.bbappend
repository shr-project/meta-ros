ROS_EXEC_DEPENDS += " \
    ament-lint-cmake-native \
"

RDEPENDS_${PN} += "ament-lint-cmake-native"

DEPENDS += "ament-lint-cmake-native"
