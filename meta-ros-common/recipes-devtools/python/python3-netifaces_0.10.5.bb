require python-netifaces.inc

inherit setuptools3

# Used by ros2cli-native
BBCLASSEXTEND = "native"
