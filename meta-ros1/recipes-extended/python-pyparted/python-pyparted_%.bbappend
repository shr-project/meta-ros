# Backport https://patchwork.openembedded.org/patch/175786/
PV = "3.11.4+git${SRCPV}"
SRCREV = "104ca13567c08c1188b126a395c4602841aae2c6"
